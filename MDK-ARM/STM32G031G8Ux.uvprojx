# Keil uVision project STM32G031G8Ux.uvprojx, settings and files
target Project (6120000::V6.12::.\ARMCLANG)
  device: STM32G031G8Ux STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") TZ
  output: STM32G031G8Ux +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G031xx
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc;../Drivers/STM32G0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G0xx/Include;../Drivers/CMSIS/Include;../BSP;..\User;..\UI;..\SEGGER_RTT\RTT;..\UI\Fonts;..\Middleware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32g031xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c spi.c usart.c stm32g0xx_it.c stm32g0xx_hal_msp.c
  group Drivers/STM32G0xx_HAL_Driver
    ../Drivers/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_ll_rcc.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_ll_dma.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_exti.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g0xx.c
  group User
    ../User/: user_test.c user_app.c user_meter.c user_menu.c user_calib.c user_ht7017.c user_com.c user_mode.c
  group BSP
    ../BSP/: bsp.c bsp_cpu_flash.c bsp_ht7017.c bsp_key.c bsp_utils.c param.c
  group Middleware
    ../Middleware/: ma_filter.c menu.c queue.c ringbuffer.c
  group UI
    ../UI/: main interface.c interface_com.c
  group GUI_Driver
    ../UI/: gui_display.c lcd_driver.c gui_draw.c
  group GUI/Font
    ../UI/Fonts/: DengXian_32.c DengXian_74.c DengXian_48.c DengXian_22.c DengXian_14.c
  group SEGGER_RTT
    ../SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../SEGGER_RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
